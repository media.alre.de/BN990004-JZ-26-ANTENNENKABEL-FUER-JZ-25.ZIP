Properties of the parts of a building model (IFC2X3)

# File
Description: Antennenkabel 1 m für externe Antenne JZ-25, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: BN990004, Antennenkabel 1 m für externe Antenne JZ-25
In: Raum
Description: Antennenkabel zur Verbindung der externen Antenne (JZ-25) mit den Mehrkanalaktoren.; Classification: EC011308 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: BN990004; ModelLabel: JZ-26; GlobalTradeItemNumber: 4050528015693; ProductURL: https://alre.de/produkt_BN990004
Pset_Specification - NominalLength: 1 m; NominalWidth: 0.003 m; NominalDepth: 0.002 m; NetWeight: 0.015
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: sonstige; Zubehör: yes; ETIM-Klasse: EC011308; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-BN990004.pdf
